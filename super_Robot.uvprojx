# Keil uVision project super_Robot.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Light_Robot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\LED;.\FWLIB\inc;.\USMART;.\HARDWARE\STMFLASH;.\SYSTEM\uart5;.\SYSTEM\usart2;.\SYSTEM\usart6;.\SYSTEM\uart4;.\SYSTEM\usart3;.\HARDWARE\BELL;.\DRIVER;.\APP;.\Middlewares\FreeRTOS\Source\include;.\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS\Include;.\Middlewares\FreeRTOS\Source\CMSIS_RTOS;.\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\DRIVER\wit_c_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: stm32f4xx_it.c system_stm32f4xx.c angle_speed.c err.c main.c bsp_init.c FreeRTOSConfig.h freertos.c watchdog.c pin.c
    ./HARDWARE/STMFLASH/: stmflash.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/BELL/: Bell.c
  group SYSTEM
    ./USER/: communicate.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c CAN.c
    ./SYSTEM/usart2/: usart2.c
    ./SYSTEM/usart3/: usart3.c
    ./SYSTEM/uart4/: uart4.c
    ./SYSTEM/uart5/: uart5.c
    ./SYSTEM/usart6/: usart6.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_tim.c stm32f4xx_can.c
  group USMART
    ./USMART/: usmart.c usmart_config.c usmart_str.c
  group DRIVER_MOTOR
    ./DRIVER/: Modbus_RTU_protocol.c motor_d_ai.c motor_drv750.c motor_config.c motor_status.h servo.c
  group APP
    ./APP/: init_task.c gimbal_task.c ins_task.c detect_task.c
  group Middlewares/FreeRTOS
    ./Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Middlewares/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ./Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group DRIVER_IMU
    ./DRIVER/wit_c_sdk/: wit_c_sdk.c REG.h
